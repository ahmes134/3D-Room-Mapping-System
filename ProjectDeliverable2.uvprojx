# Keil uVision project ProjectDeliverable2.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Studio4A
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: PLL.c SysTick.c vl53l1_platform.h VL53L1X_api.c uart.c onboardLEDs.c OnboardButton.c OnboardButton.h StepperMotor.c StepperMotor.h ProjectDeliverable2_Bonus.c
    ../Lab8/2DX_2024_Studio_8/: vl53l1_platform_2dx4.c
software components: CMSIS:CORE 5.4.0, Device:Startup 3.2.3
